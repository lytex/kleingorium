File: kleingorium.kicad_sch (KiCad schematic)
At the start: 4 parts, among them J1 VCC, J2 VCC, J3 GND, J4 GND

Commit message: wip symmetric layout
Other:
- moved on the sheet: J1, J2, J3, J4
